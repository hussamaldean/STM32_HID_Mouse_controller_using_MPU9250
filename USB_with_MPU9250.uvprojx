# Keil uVision project USB_with_MPU9250.uvprojx, settings and files
target STM32F429ZI-Disco (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB_course
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./: main.c
  group helper_v2
    ./: helperv2.c helperv2.h
  group USB
    ./: usbd_driver.h usbd_framework.h usbd_driver.c usbd_framework.c usb_standards.h usb_device.h usbd_descriptors.h
  group HID
    ./: usb_hid_standard.h usb_hid.h usb_hid_usage_button.h usb_hid_usage_desktop.h
  group MPU9250
    ./: MPU9250.c MPU9250.h i2c.h i2c.c
  group Blinking_LED
    ./: blinking.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
